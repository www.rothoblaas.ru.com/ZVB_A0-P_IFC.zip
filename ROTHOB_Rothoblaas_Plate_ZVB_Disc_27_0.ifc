Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, QuantityTakeOffAddOnView], RevitIdentifiers [VersionGUID: c9e0ca5f-e6b7-42b8-a35c-3e24e9abccf4, NumberOfSaves: 73], CoordinateReference [CoordinateBase: Project Base Point, ProjectSite: Default Site]
File name: ROTHOB_Rothoblaas_Plate_ZVB_Disc_27_0.ifc
Time: 2026-07-17T08:46:50
Written by: ODA IFC SDK 22.8
Made in: 22.1.80.32 - IFC 22.7.0.0 - Default UI

# IfcProject, 01
LongName: ROTHOBLAAS

# IfcSite, Default
RefLatitude: 46, 17, 24, 511413; RefLongitude: 11, 14, 5, 895767; RefElevation: 0 mm
Identity Data - Author: ROTHOBLAAS; Building Name: HEADQUARTER; Organization Name: ROTHO BLAAS SRL
Other - Category: Project Information; Client Name: Owner; Project Address: Via dell'Adige N. 2/1, Cortaccia (BZ) [ITA]; Project Name: ROTHOBLAAS; Project Number: 01

# IfcBuilding, HEADQUARTER
LongName: HEADQUARTER
Pset_BuildingCommon - NumberOfStoreys: 1
Identity Data - Author: ROTHOBLAAS; Building Name: HEADQUARTER; Organization Name: ROTHO BLAAS SRL
Other - Category: Project Information; Client Name: Owner; Project Address: Via dell'Adige N. 2/1, Cortaccia (BZ) [ITA]; Project Name: ROTHOBLAAS; Project Number: 01

# IfcBuildingStorey: Level:1/4" Head, 0_Rothoblaas
In: HEADQUARTER
LongName: 0_Rothoblaas; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: 0_Rothoblaas; sets with these values: 2
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: 0_Rothoblaas; Structural: no
Other - Category: Levels; Family: Level; Family and Type: Level: 1/4" Head; Type: 1/4" Head; Type Id: 27
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Grid Line 1/2"; Line Weight: 1; Symbol: Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: 1/4" Head
Other(Type) - Category: Levels; Family Name: Level

# IfcDiscreteAccessory: Structural Connections : ROTHOB_Rothoblaas_Plate_ZVB_Disc : ZVBDISC27_302x22mm
In: 0_Rothoblaas
Type - Material: ROTHOB_Rothoblaas_CarbonSteel_S355
Type - General - Author: Augusto Meorali; BIMObjectName: ROTHOB_Rothoblaas_Plate_ZVB_Disc; ManufacturerName: ROTHO BLAAS SRL; ManufacturerURL: www.rothoblaas.com; OmniClassCode: 23.25.30.14.11; OmniClassTitle: Booms, Braces; OmniClassVersion: 2012-05-16; ProductInformation: www.rothoblaas.com/products/fastening/brackets-and-plates/bracings/zvb; Revision: 000; UniClass2015Code: Pr_20_85_84_88; UniClass2015Title: Tension or compression bracing products; UniClass2015Version: Products v1.42; Version: 001
Type - Constraints - Default Elevation: 0 mm; ModelNumberCode: 27
Type - Materials and Finishes - ObjectMaterial: ROTHOB_Rothoblaas_CarbonSteel_S355
Type - Dimensions - DiameterHolePosition_Dhp: 200 mm; DiameterHoles_Dh: 28 mm; ExternalDiameter_De: 302 mm; Height_H: 302 mm; InternalDiameter_Di: 88 mm; Length_L: 22 mm; RadiusHolePosition_Rhp: 100 mm; Thickness_s: 22 mm; Width_B: 302 mm
Type - Identity Data - Description: Disk for bracings; Manufacturer: info@rothoblaas.com; OmniClass Number: 23.25.30.14.11; OmniClass Title: Booms, Braces; Type Name: ZVBDISC27_302x22mm
Type - Other - Category: Structural Connections; AccessibilityPerformance: n/a; AssetType: Fixed; CECode: n/a; CETitle: n/a; CodePerformance: n/a; Color: Silver; Constituents: n/a; DurationUnit: Years; ExpectedLife: 25; Family Name: ROTHOB_Rothoblaas_Plate_ZVB_Disc; Features: Bracing; Finish: Hot dip galvanising; Grade: n/a; GTIN: n/a; Material: S355 Carbon Steel; MinWeight: n/a; ModelDisclaimer: The latest version of the data sheets can be found on our website; ModelNumber: n/a; ModelReference: n/a; Name: Plate; NominalHeight: 302 mm; NominalLength: 22 mm; NominalWidth: 302 mm; ReplacementCost: n/a; Shape: Three-dimensional; Size: 302x302x22 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: n/a; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Pset_ElementShading - Color: Silver
Type - Pset_ManufacturerTypeInformation - ModelReference: n/a; Manufacturer: info@rothoblaas.com
Type - Pset_ProductRequirements - Name: Plate
Pset_QuantityTakeOff - Reference: ZVBDISC27_302x22mm
Constraints - Elevation from Level: 0 mm; Host: Level : 0_Rothoblaas; Level: 0_Rothoblaas; Schedule Level: 0_Rothoblaas
Phasing - Phase Created: New Construction
Dimensions - Area: 0.0797219 m2; TiltingAngle_º: 0 deg; Volume: 0.00141493 m3
Other - Family: ROTHOB_Rothoblaas_Plate_ZVB_Disc; Family and Type: ROTHOB_Rothoblaas_Plate_ZVB_Disc: ZVBDISC27_302x22mm; InstallationDate: n/a; Type: ZVBDISC27_302x22mm; Type Id: 2094332; WarrantyStartDate: n/a
